# Keil uVision project KL25_UART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: KL25_UART
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./: startup_MKL25Z4.s kiss_fft.c _kiss_fft_guts.h ADC.h delay.h FFT.h UART.h main.cpp kiss_fft.h system_MKL25Z4.h system_MKL25Z4.c user_defs.h
